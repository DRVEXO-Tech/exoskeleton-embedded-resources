# Keil uVision project CORE.uvprojx, settings and files
target CORE (6230000::V6.23::ARMCLANG)
  device: STM32H563VGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.1.1
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x08000000-0x80FFFFF)  CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: CORE +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H563xx
  c misc: -Wno-deprecated-non-prototype
  c include: ../Core/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc;../Drivers/STM32H5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H5xx/Include;../Drivers/CMSIS/Include;../APP/Inc;../Device/Inc;../Platform/Inc;../Sys/Inc;../Algorithm/IMU/Inc;../Algorithm/PID/Inc;../User_Data/Inc;..\Shell\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  link misc: --keep shellCommand*
--keep shellVariable*
  group Application/MDK-ARM
    ./: startup_stm32h563xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c fdcan.c gpdma.c icache.c spi.c tim.c usart.c stm32h5xx_it.c stm32h5xx_hal_msp.c
  group Drivers/STM32H5xx_HAL_Driver
    ../Drivers/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_adc.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_flash.c stm32h5xx_hal_flash_ex.c stm32h5xx_hal_gpio.c stm32h5xx_hal_pwr.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cortex.c stm32h5xx_hal.c stm32h5xx_hal_exti.c stm32h5xx_hal_crc.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_fdcan.c stm32h5xx_hal_icache.c stm32h5xx_hal_spi.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h5xx.c
  group Sys
    ../Sys/Inc/: config.h
    ../Sys/Src/: DRVEXO_Scheduler.c Sys.c
  group Platform
    ../Platform/Src/: Platform_FDCAN.c Platform_GPIO.c Platform_SPI.c Platform_UART.c Platform_TIM.c
  group Device
    ../Device/Src/: Device_FDCAN.c Device_W25N01KV.c Decive_LPS27HHTW.c Device_ISM6DSO.c Device_VOICE.c Device_IO_Control.c
  group APP
    ../APP/Src/: APP_FDCAN.c APP_LowPower.c APP_ISM6DSO.c APP_LPS27HHTW.c APP_VOICE.c APP_Control.c APP_LED.c
  group Algorithm/IMU
    ../Algorithm/IMU/Src/: DRVEXO_IMU.c DRVEXOAhrs.c DRVEXOBias.c DRVEXOCompass.c
  group Algorithm/PID
    ../Algorithm/PID/Src/: PID.c
  group README
    ../README/: version.txt
  group User_Data
    ../User_Data/Src/: User_Data.c User_main.c
  group Shell
    ../Shell/Src/: cmd.c ring.c shell.c shell_ext.c
software components: CMSIS:CORE 4.3.0
